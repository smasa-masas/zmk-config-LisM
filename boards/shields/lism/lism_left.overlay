#include "lism.dtsi"

&spi0 {
    /* 左手側ではSPI（トラックボール通信）を無効化して、D5ピンを解放する */
    status = "disabled";
};

&encoder {
    /* 解放されたピンを使ってエンコーダーを有効化する */
    status = "okay";
};
